# Keil uVision project freertos_solor.uvprojx, settings and files
target at_start_f403a_ac5 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.8
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a_freertos_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c misc: --c99
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f403a_407_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F;..\..\..\project\I2C;..\..\..\project\ina226;..\..\..\project\TIMR;..\..\..\project\acqBoard;..\..\..\project\SPI;..\..\..\project\OLED;..\..\..\project\ADC;..\..\..\project\CtlLoop;..\..\..\project\charge;..\..\..\project\filter;..\..\..\project\mppt;..\..\..\project\ESP8266;..\..\..\project\RTT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c include_port.c
  group bsp
    ../../../project/at32f403a_407_board/: at32f403a_407_board.c
    ../../../project/I2C/: soft_iic.c
    ../../../project/TIMR/: timer.c
    ../../../project/SPI/: spi.c
    ../../../project/ADC/: adc.c
  group module
    ../../../project/ina226/: ina226.c
    ../../../project/CtlLoop/: CtlLoop.c
    ../../../project/charge/: charge.c
    ../../../project/filter/: filter.c
    ../../../project/mppt/: mppt.c
    ../../../project/ESP8266/: esp8266.c
    ../../../project/OLED/: oled.c
  group RTT
    ../../../project/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_FreeRTOS.c
  group firmware
    ../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c printf-stdarg.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target at_start_f407_ac5 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.8
  cpu: as above
  output: at32f407_freertos_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f403a_407_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target at_start_f403a_ac6 (6190000::V6.19::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.8
  cpu: as above
  output: at32f403a_freertos_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f403a_407_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target at_start_f407_ac6 (6160000::V6.16::ARMCLANG)
  device: -AT32F407VGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.8
  cpu: as above
  output: at32f407_freertos_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
